# Keil uVision project sd-card.uvproj, settings and files
target SDCard (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SDCard +hex
  AfterMake: fromelf.exe --bin -o .\build\SDCard.bin  .\build\SDCard.axf
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: ./inc;./driver/inc;./library/clib;./library/hl;./library/fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ./asm/: startup_stm32f10x_cl.s
  group app
    ./src/: main.c system_stm32f10x.c app_upgrade.c code_protect.c led.c sd_card.c irq.c uart.c global_variables.c iwdg.c helper.c
  group driver
    ./driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hl
    ./library/hl/: hl_iap.c hl_timer.c
  group clib
    ./library/clib/: cl_atomic.c cl_queue.c
  group fatfs
    ./library/fatfs/: diskio.c ff.c
